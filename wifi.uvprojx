# Keil uVision project wifi.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: switches_leds_mod
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: km_startup.s main.c km_tm4c123gh6pm.h pll.c pll.h KM_SysTickTimer.c dht11.c lcd.c rtc.c RTC_LCD.c
    ../UART_LoopBack_Polling/: KM_SysTickTimer.h
